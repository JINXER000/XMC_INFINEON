# Keil uVision project test222.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: XMC4700-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.10.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test222 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\cores;.\libraries\Wire\src\utility;.\libraries\SPI\src\utility;.\libraries\SPI\src;.\libraries\Wire\src;.\cores\xmc_lib\LIBS;..\test222;.\SLS10ERE1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group others
    ./cores/: dtostrf.c itoa.c wiring_digital.c Main.cpp
    ./libraries/Wire/src/utility/: xmc_i2c_conf.c
    ./: cppforXMC4700.cpp BspUsart.cpp driver.cpp Receive.cpp
    ./libraries/SPI/src/utility/: xmc_spi_conf.c
  group mm
    ./libraries/Wire/src/: Wire.cpp
    ./cores/: new.cpp abi.cpp Print.cpp RingBuffer.cpp Stream.cpp WString.cpp
    ./libraries/SPI/src/: HW_SPI.cpp SW_SPI.cpp
    ./: common.h Dps310.cpp timer.cpp
  group bsp
    ./: board.c test_case.c
    ./cores/: Button.c pin_interrupt.c pin_interrupt_conf.c
  group SLS10ERE1
    ./SLS10ERE1/: SLS10ERE_auth.c SLS10ERE_crypto.c SLS10ERE_math.c SLS10ERE_nvm.c SLS10ERE_SWI_BIF.c SWI_hal.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:RTE_Device 1.1.0, Device:Startup 2.2.0, Device:XMClib:CCU4 2.1.18, Device:XMClib:CCU8 2.1.18, Device:XMClib:DAC 2.1.18, Device:XMClib:ERU 2.1.18, Device:XMClib:GPIO 2.1.18, Device:XMClib:I2C 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:SPI 2.1.18, Device:XMClib:UART 2.1.18, Device:XMClib:VADC 2.1.18
